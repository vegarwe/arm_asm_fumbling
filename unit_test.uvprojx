# Keil uVision project unit_test.uvprojx, settings and files
target Simulator (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: Simulator +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_DFU_APP_SUPPORT __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S332 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 NRF_LOG_USES_RAW_UART=1 CONFIG_GPIO_AS_PINRESET SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52 BSP_DEFINES_ONLY NO_DISPLAY DEBUG DK_GPIO_DEBUG NO_WATCHDOG
  c include: ..\..\src\config;..\..\src\sdk_modified;..\..\..\nrf_sdk\components\ble\ble_services\ble_bas;..\..\..\nrf_sdk\components\ble\ble_services\ble_dfu;..\..\..\nrf_sdk\components\ble\ble_services\ble_dis;..\..\..\nrf_sdk\components\ble\ble_services\ble_hrs;..\..\..\nrf_sdk\components\ble\ble_services\ble_ancs_c;..\..\..\nrf_sdk\components\ble\ble_services\ble_ans_c;..\..\..\nrf_sdk\components\ble\ble_services\ble_cts_c;..\..\..\nrf_sdk\components\ble\common;..\..\..\nrf_sdk\components\ble\device_manager;..\..\..\nrf_sdk\components\ble\ble_db_discovery;..\..\..\nrf_sdk\components\drivers_nrf\common;..\..\..\nrf_sdk\components\drivers_nrf\config;..\..\..\nrf_sdk\components\drivers_nrf\delay;..\..\..\nrf_sdk\components\drivers_nrf\gpiote;..\..\..\nrf_sdk\components\drivers_nrf\hal;..\..\..\nrf_sdk\components\drivers_nrf\ppi;..\..\..\nrf_sdk\components\drivers_nrf\pstorage;..\..\..\nrf_sdk\components\drivers_nrf\uart;..\..\..\nrf_sdk\components\drivers_nrf\wdt;..\..\..\nrf_sdk\components\libraries\bootloader_dfu;..\..\..\nrf_sdk\components\libraries\button;..\..\..\nrf_sdk\components\libraries\crc32;..\..\..\nrf_sdk\components\libraries\experimental_section_vars;..\..\..\nrf_sdk\components\libraries\fifo;..\..\..\nrf_sdk\components\libraries\fstorage\config;..\..\..\nrf_sdk\components\libraries\fstorage;..\..\..\nrf_sdk\components\libraries\sensorsim;..\..\..\nrf_sdk\components\libraries\timer;..\..\..\nrf_sdk\components\libraries\trace;..\..\..\nrf_sdk\components\libraries\uart;..\..\..\nrf_sdk\components\libraries\util;..\..\..\nrf_sdk\components\softdevice\common\softdevice_handler;..\..\..\nrf_sdk\components\softdevice\s332\headers;..\..\..\nrf_sdk\components\softdevice\s332\headers\nrf52;..\..\..\nrf_sdk\components\toolchain;..\..\..\nrf_sdk\examples\bsp;..\..\..\nrf_sdk\external\segger_rtt;..\..\src;..\..\src\analysis;..\..\src\app;..\..\src\battery;..\..\src\ble;..\..\src\button;..\..\src\debug;..\..\src\display;..\..\src\factory_reset;..\..\src\lib;..\..\src\prod_test;..\..\src\sensors;..\..\src\storage;..\..\src\vibrator;..\..\lib_alg;..\Unity\src;..\..\..\nrf_sdk\components\libraries\log;..\..\slice\src\config;..\..\..\nrf_sdk\components\libraries\log\src
  asm define: BLE_DFU_APP_SUPPORT __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S332 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF_LOG_USES_RTT=1 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x59000
  memory RVCT9: RAM 0x20003800 size 0xc800
  group Application
    ./: fisken.asm
  group Unit_test
    ../Unity/src/: unity.c
    ./: unit_test.c
    ../: nrf_log.c
  group Simulator
    ../: simulator.ini
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
